## scriptexecute/Config.in
```kconfig
source "$BR2_EXTERNAL_SCRIPTEXECUTE_PATH/package/rpi-firmware-custom/Config.in"
source "$BR2_EXTERNAL_SCRIPTEXECUTE_PATH/package/flashrom-custom/Config.in"
```
